# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\DataType;..\HW\RCC;..\HW\Timer;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\LED;..\HW\UltraSound;..\HW\server;..\HW\UltraSound1;..\HW\Encode;..\HW\LCD;..\HW\PWM;..\HW\EXTI;..\HW\TFTCON;..\HW\UART1;..\HW\DS18B20;..\HW\sys;..\HW\usart3;..\HW\ASRPRO;..\HW\BTHCON;..\HW\HC-05
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c
    ../HW/UltraSound/: UltraSound.c
    ../HW/server/: server.c
    ../HW/UltraSound1/: UltraSound1.c
    ../HW/Encode/: Encoder.c
    ../HW/LCD/: lcd.c lcd_init.c
    ../HW/PWM/: PWM.c
    ../HW/EXTI/: EXTI.c
    ../HW/TFTCON/: TFTCON.c
    ../HW/DS18B20/: ds18b20.c
    ../HW/sys/: sys.c
    ../HW/usart3/: usart3.c
    ../HW/ASRPRO/: ASRPRO.c
    ../HW/HC-05/: HC05.c Serial.c
    ../HW/BTHCON/: BTHCON.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
